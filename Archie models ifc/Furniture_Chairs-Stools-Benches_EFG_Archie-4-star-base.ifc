Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Chairs-Stools-Benches_EFG_Archie-4-star-base.ifc
Time: 2021-06-03T14:37:29
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Archie 4 star base
ePset_BIMobjectScript - Type: Plastic; Frame Color: White; Shell Color: Navy Blue - Plastic; Seat Color: Beige - Fabric; Back Fabric: Beige - Fabric; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Archie 4 star base; SKU (BO_prodsku): ARCJ; ManufacturName (BO_Manufac): EFG; BrandUrl (BO_brandurl): http://www.efg.se; ProductFamily (BO_prodfam): EFG Seating; ProductGroup (BO_prodgroup): Archie; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; PublishDate (BO_publisdat): 7/12/2019; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/efg/product/ARCJ; ProductDataUrl (BO_prodaturl): bimobject.com/efg/product/ARCJ; ProductUrl (BO_producturl): http://www.efg.info/en/Products/Chairs/EFG-Archie/?tab=Downloads; ProductCertification (BO_prodcert): http://www.efg.info/en/Products/Chairs/EFG-Archie/?tab=Downloads; TechnicalDescription (BO_techcert): http://www.efg.info/en/Products/Chairs/EFG-Archie/?tab=Facts; MaterialMain (BO_mainmat): Fabric; MaterialSecondary (BO_secmat): Metal; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Chairs, Stools & Benches; BimObjectCategoryCode (BO_bocat_code): furniture-chairs-stools-benches; IfcClassification (BO_ifcclas): Furniture; UnspscCode (BO_unspsc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8222; Uniclass14Description (BO_uniclass_1_4_desc): Chairs; Uniclass20Code (BO_uniclass_2_0_code): PR-31-12; Uniclass20Description (BO_uniclass_2_0_desc): Chairs, Seats And Bench Seating; Uniclass2015Code (BO_uniclass2015_code): Pr_40_50_12; Uniclass2015Description (BO_uniclass2015_desc): Chairs, seats and benches; NBSReference (BO_nbs_ref): 31-12; NBSReferenceDescription (BO_nbs_desc): Chairs, Seats And Bench Seating; OmniClassCode (BO_omniclass_code): 23-21 23 13 11; OmniClassDescription (BO_omniclass_name): Residential Chairs; MasterFormat2014Code (BO_masterformat2014_code): 12 52 13; MasterFormat2014Description (BO_masterformat2014_name): Chairs; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA
